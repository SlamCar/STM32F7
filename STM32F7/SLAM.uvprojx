# Keil uVision project SLAM.uvprojx, settings and files
target APP (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: SLAM +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: .\USER;.\CORE;.\SYSTEM\sys;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HALLIB\Inc;.\OS\STM32\RTOS\UCOSIII\uC-LIB;.\OS\STM32\RTOS\UCOSIII\uC-CPU;.\OS\STM32\RTOS\UCOSIII\UCOS-BSP;.\OS\STM32\RTOS\UCOSIII\UCOS-CONFIG;.\OS\STM32\RTOS\UCOSIII\uCOS-III\Source;.\OS\STM32\RTOS\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;.\OS\STM32\RTOS\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;.\OS\STM32\RTOS\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;.\DRIVER\LED;.\DRIVER\KEY;.\DRIVER\UART
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./USER/: main.c Protocal.h Data_Base.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c stm32f7xx.h stm32f7xx_hal_conf.h stm32f7xx_hal_msp.c stm32f7xx_it.c stm32f7xx_it.h stm32f767xx.h sys.h system_stm32f7xx.c system_stm32f7xx.h
  group DRIVER
    ./DRIVER/LED/: led.c
    ./DRIVER/KEY/: key.c
    ./DRIVER/UART/: UART_Interface.c
  group HALLIB
    ./HALLIB/Src/: stm32f7xx_hal.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_spi.c stm32f7xx_ll_sdmmc.c
  group OS
    ./OS/STM32/RTOS/UCOSIII/UCOS-BSP/: bsp.c
    ./OS/STM32/RTOS/UCOSIII/uC-CPU/: cpu_core.c
    ./OS/STM32/RTOS/UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./OS/STM32/RTOS/UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ./OS/STM32/RTOS/UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ./OS/STM32/RTOS/UCOSIII/UCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
    ./OS/STM32/RTOS/UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ./OS/STM32/RTOS/UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group CORE
    ./CORE/: cmsis_armcc.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
